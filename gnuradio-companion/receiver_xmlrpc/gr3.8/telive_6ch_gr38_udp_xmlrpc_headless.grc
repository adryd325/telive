options:
  parameters:
    author: Jacek Lipkowski SQ5BPF
    category: Custom
    generate_options: no_gui
    id: top_block
    output_language: python
    run_options: run
    title: SQ5BPF Tetra live receiver 6ch UDP HEADLESS
  states: {}

blocks:
- name: first_decim
  id: variable
  parameters:
    value: '32'
  states: {}
- name: first_port
  id: variable
  parameters:
    value: '42000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: if_samp_rate
  id: variable
  parameters:
    value: samp_rate/first_decim
  states: {}
- name: options_low_pass
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: out_sample_rate
  id: variable
  parameters:
    value: '36000'
  states: {}
- name: ppm_corr
  id: variable
  parameters:
    value: '56'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sdr_gain
  id: variable
  parameters:
    value: '38'
  states: {}
- name: sdr_ifgain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: telive_receiver_channels
  id: variable
  parameters:
    value: '6'
  states: {}
- name: telive_receiver_name
  id: variable
  parameters:
    value: '''SQ5BPF 6-channel headless rx for telive'''
  states: {}
- name: udp_dest_addr
  id: variable
  parameters:
    value: '"127.0.0.1"'
  states: {}
- name: udp_packet_size
  id: variable
  parameters:
    value: '1472'
  states: {}
- name: xlate_offset1
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: xlate_offset2
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: xlate_offset3
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: xlate_offset4
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: xlate_offset5
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: xlate_offset6
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: xlate_offset_fine1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: xlate_offset_fine2
  id: variable
  parameters:
    value: '0'
  states: {}
- name: xlate_offset_fine3
  id: variable
  parameters:
    value: '0'
  states: {}
- name: xlate_offset_fine4
  id: variable
  parameters:
    value: '0'
  states: {}
- name: xlate_offset_fine5
  id: variable
  parameters:
    value: '0'
  states: {}
- name: xlate_offset_fine6
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc3_xx_0_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc3_xx_0_0_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc3_xx_0_0_0_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc3_xx_0_0_0_0_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc3_xx_0_0_0_0_0_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: udp_dest_addr
    port: first_port+1
    psize: udp_packet_size
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: udp_dest_addr
    port: first_port+2
    psize: udp_packet_size
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_1
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: udp_dest_addr
    port: first_port+3
    psize: udp_packet_size
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_2
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: udp_dest_addr
    port: first_port+4
    psize: udp_packet_size
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_3
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: udp_dest_addr
    port: first_port+6
    psize: udp_packet_size
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_4
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: udp_dest_addr
    port: first_port+5
    psize: udp_packet_size
    type: complex
    vlen: '1'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_offset1+xlate_offset_fine1
    decim: first_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_offset2+xlate_offset_fine2
    decim: first_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_offset3+xlate_offset_fine3
    decim: first_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_offset4+xlate_offset_fine4
    decim: first_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_offset5+xlate_offset_fine5
    decim: first_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_offset6+xlate_offset_fine6
    decim: first_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)
    type: ccc
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(float(if_samp_rate)/float(out_sample_rate))
    type: complex
  states: {}
- name: mmse_resampler_xx_1
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(float(if_samp_rate)/float(out_sample_rate))
    type: complex
  states: {}
- name: mmse_resampler_xx_2
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(float(if_samp_rate)/float(out_sample_rate))
    type: complex
  states: {}
- name: mmse_resampler_xx_3
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(float(if_samp_rate)/float(out_sample_rate))
    type: complex
  states: {}
- name: mmse_resampler_xx_4
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(float(if_samp_rate)/float(out_sample_rate))
    type: complex
  states: {}
- name: mmse_resampler_xx_5
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(float(if_samp_rate)/float(out_sample_rate))
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    corr0: ppm_corr
    freq0: freq
    gain0: sdr_gain
    gain_mode0: 'False'
    if_gain0: sdr_ifgain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: first_port
  states: {}

connections:
- [analog_agc3_xx_0, '0', mmse_resampler_xx_5, '0']
- [analog_agc3_xx_0_0, '0', mmse_resampler_xx_4, '0']
- [analog_agc3_xx_0_0_0, '0', mmse_resampler_xx_3, '0']
- [analog_agc3_xx_0_0_0_0, '0', mmse_resampler_xx_2, '0']
- [analog_agc3_xx_0_0_0_0_0, '0', mmse_resampler_xx_0, '0']
- [analog_agc3_xx_0_0_0_0_0_0, '0', mmse_resampler_xx_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc3_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_agc3_xx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', analog_agc3_xx_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', analog_agc3_xx_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0, '0', analog_agc3_xx_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0_0, '0', analog_agc3_xx_0_0_0_0_0_0, '0']
- [mmse_resampler_xx_0, '0', blocks_udp_sink_0_4, '0']
- [mmse_resampler_xx_1, '0', blocks_udp_sink_0_3, '0']
- [mmse_resampler_xx_2, '0', blocks_udp_sink_0_2, '0']
- [mmse_resampler_xx_3, '0', blocks_udp_sink_0_1, '0']
- [mmse_resampler_xx_4, '0', blocks_udp_sink_0_0, '0']
- [mmse_resampler_xx_5, '0', blocks_udp_sink_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0_0_0, '0']

metadata:
  file_format: 1
